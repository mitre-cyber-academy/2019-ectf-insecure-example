IMAGE_INSTALL_append = " mesh-game-loader"
IMAGE_INSTALL_append = " uioctl"
IMAGE_INSTALL_append = " peekpoke"
